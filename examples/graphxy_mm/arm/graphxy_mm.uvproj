# Keil uVision project graphxy_mm.uvproj, settings and files
target graphxy_mm (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: graphxy_mm
  AfterMake: fromelf.exe --bin --output obj\graphxy_mm.bin obj\graphxy_mm.axf
  c flags: Optim=4
  c define: EFM32G890F128 DEBUG_EFM ENERGY_AWARE
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\reptile\emwin\inc;..\..\..\..\..\reptile\glib;..\..\..\..\common\drivers\emwin\Dk3550;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../: startup_efm32g.s
    ../../../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_adc.c em_cmu.c em_emu.c em_system.c em_rtc.c em_wdog.c em_gpio.c em_ebi.c em_usart.c em_i2c.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: calibrate.c touch.c eeprom.c i2cdrv.c
  group emwin
    ../../../../common/drivers/emwin/Dk3550/: GUI_X.c GUIConf.c LCDConf.c ssd2119.c
  group Source
    ../: WIDGET_GraphXY.c
  group Libraries
    ../../../../../reptile/emwin/lib/: emwin_ARM_CM3.lib
